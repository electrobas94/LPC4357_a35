# Keil uVision project Adunok3.5.uvproj, settings and files
target Target 1 (5060020::V5.06 (build 20)::ARMCC)
  device: LPC4357 NXP
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x20000000-0x2000FFFF) IROM(0x1A000000-0x1A07FFFF) IROM2(0x1B000000-0x1B07FFFF) CLOCK(12000000) CPUTYPE("Cortex-M4") FPU2
  output: Adunok3.5 +hex
  c flags: Optim=1 wLevel=1
  c define: CORE_M4
  c include: .\include;.\Drivers\include;.\Board\Include
  library: MicroLIB
  memory RVCT4: ROM 0x1a000000 size 0x80000
  memory RVCT5: ROM 0x1b000000 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20000000 size 0x10000
  group Startup
    ./: startup_LPC43xx.s
  group Source
    ./src/: main.c
  group Drivers
    ./Drivers/source/: debug_frmwrk.c Font5x7.c ipc_buffer.c ipc_cmd_buffer.c ipc_int.c ipc_mbx.c ipc_msg_buffer.c ipc_queue.c LCDTerm.c lpc43xx_adc.c lpc43xx_atimer.c lpc43xx_can.c lpc43xx_cgu.c lpc43xx_dac.c lpc43xx_emc.c lpc43xx_evrt.c lpc43xx_gpdma.c lpc43xx_gpio.c lpc43xx_i2c.c lpc43xx_i2s.c lpc43xx_lcd.c lpc43xx_mcpwm.c lpc43xx_nvic.c lpc43xx_pwr.c lpc43xx_qei.c lpc43xx_rgu.c lpc43xx_rit.c lpc43xx_rtc.c lpc43xx_sct.c lpc43xx_scu.c lpc43xx_sdif.c lpc43xx_sdmmc.c lpc43xx_ssp.c lpc43xx_timer.c lpc43xx_uart.c lpc43xx_wwdt.c sdio.c
  group Board
    ./Board/Source/: fpu_init.c fpu_enable.c
    ./Board/Source/Templates/: system_LPC43xx.c
